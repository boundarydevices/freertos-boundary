<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>ddr_debug</configuration>
      </member>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>ddr_release</configuration>
      </member>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>flash_debug</configuration>
      </member>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ddr_debug</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>ddr_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ddr_release</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>ddr_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_debug</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>flash_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flash_release</name>
      <member>
        <project>sai_sdma_record_playback</project>
        <configuration>flash_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/sai_sdma_record_playback.ewp</path>
  </project>
</workspace>
