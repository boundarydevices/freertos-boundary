# IAR project rpmsg_lite_pingpong_rtos_linux_remote.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8ML8_M7 NXP MIMX8ML8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7; ../../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../../devices/MIMX8ML8/drivers; ../../../../../../rtos/freertos/freertos_kernel/include; ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../../devices/MIMX8ML8; ../../../../../../devices/MIMX8ML8/utilities/str; ../../../../../../devices/MIMX8ML8/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_rtos_linux_remote.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: DEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CPU_MIMX8ML8DVNLZ; CPU_MIMX8ML8DVNLZ_cm7; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; FLASH_TARGET; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_ddr_ram.icf
  group source
    ../: main_remote.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h rpmsg_config.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group rpmsg_lite/include
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/include/platform/imx8mp_m7
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7/: rpmsg_platform.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imx8mp_m7
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mp_m7/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/common
    ../../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/virtio
    ../../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group freertos/freertos_kernel
    ../../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/portable
    ../../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/include
    ../../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group drivers
    ../../../../../../devices/MIMX8ML8/drivers/: fsl_clock.h fsl_clock.c fsl_mu.h fsl_mu.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_rdc.h fsl_rdc.c fsl_audiomix.h fsl_audiomix.c fsl_uart.h fsl_uart.c
  group device
    ../../../../../../devices/MIMX8ML8/: fsl_device_registers.h MIMX8ML8_cm7.h MIMX8ML8_cm7_features.h system_MIMX8ML8_cm7.c system_MIMX8ML8_cm7.h
  group utilities
    ../../../../../../devices/MIMX8ML8/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8ML8/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX8ML8/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8ML8/iar/: startup_MIMX8ML8_cm7.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
