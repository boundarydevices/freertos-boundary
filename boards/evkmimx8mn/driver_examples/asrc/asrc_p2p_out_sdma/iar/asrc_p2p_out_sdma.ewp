# IAR project asrc_p2p_out_sdma.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MN6_M7 NXP MIMX8MN6_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MIMX8MN6DVTJZ; CPU_MIMX8MN6DVTJZ_cm7; SDK_DELAY_USE_DWT; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8524_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../components/codec/wm8524; ../../../../../../devices/MIMX8MN6/drivers; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8524; ../../../../../../components/codec/port; ../../../../../../devices/MIMX8MN6/utilities/str; ../../../../../../devices/MIMX8MN6/utilities/debug_console_lite; ../../../../../../devices/MIMX8MN6; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: easrc_p2p_out_sdma.bin
  ILINK.IlinkOutputFile: asrc_p2p_out_sdma.out
  ILINK.IlinkIcfFile: MIMX8MN6xxxxx_cm7_ddr_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group source
    ../: asrc_p2p_out_sdma.c music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group codec
    ../../../../../../components/codec/wm8524/: fsl_wm8524.h fsl_wm8524.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8524
    ../../../../../../components/codec/port/wm8524/: fsl_codec_wm8524_adapter.c fsl_codec_wm8524_adapter.h
  group drivers
    ../../../../../../devices/MIMX8MN6/drivers/: fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_sdma.h fsl_sai_sdma.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_asrc.h fsl_asrc_firmware.h fsl_asrc.c fsl_asrc_sdma.h fsl_asrc_sdma.c fsl_rdc.h fsl_rdc.c fsl_uart.h fsl_uart.c fsl_memory.h
  group utilities
    ../../../../../../devices/MIMX8MN6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8MN6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../../../../../../devices/MIMX8MN6/: fsl_device_registers.h MIMX8MN6_cm7.h MIMX8MN6_cm7_features.h system_MIMX8MN6_cm7.c system_MIMX8MN6_cm7.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8MN6/iar/: startup_MIMX8MN6_cm7.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
