# IAR project cmsis_ii2c_int_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MQ6_M4 NXP MIMX8MQ6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MQ6DVAJZ
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MIMX8MQ6/utilities/debug_console_lite; ../../../../../../../devices/MIMX8MQ6/drivers; ../../../../../../../devices/MIMX8MQ6/cmsis_drivers; ../../../../../../../devices/MIMX8MQ6; ../../../../../../../components/uart; ../../../../../../../components/lists; ../../../../../../../CMSIS/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: cmsis_ii2c_int_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MQ6DVAJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
  group source
    ../: cmsis_i2c_int_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group utilities
    ../../../../../../../devices/MIMX8MQ6/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../../devices/MIMX8MQ6/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_rdc.h fsl_rdc.c fsl_uart.h fsl_uart.c fsl_i2c.h fsl_i2c.c
    ../../../../../../../devices/MIMX8MQ6/cmsis_drivers/: fsl_i2c_cmsis.h fsl_i2c_cmsis.c
  group device
    ../../../../../../../devices/MIMX8MQ6/: fsl_device_registers.h MIMX8MQ6_cm4.h MIMX8MQ6_cm4_features.h system_MIMX8MQ6_cm4.c system_MIMX8MQ6_cm4.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../../devices/MIMX8MQ6/iar/: startup_MIMX8MQ6_cm4.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_I2C.h Driver_Common.h
