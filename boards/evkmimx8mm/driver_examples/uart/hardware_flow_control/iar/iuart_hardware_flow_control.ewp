# IAR project iuart_hardware_flow_control.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MM6_M4 NXP MIMX8MM6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8MM6/drivers; ../../../../../../devices/MIMX8MM6; ../../../../../../devices/MIMX8MM6/utilities/str; ../../../../../../devices/MIMX8MM6/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: iuart_hardware_flow_control.out
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH_TARGET; CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_ddr_ram.icf
  group source
    ../: uart_hardware_flow_control.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../devices/MIMX8MM6/drivers/: fsl_uart.h fsl_uart.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_rdc.h fsl_rdc.c
  group device
    ../../../../../../devices/MIMX8MM6/: fsl_device_registers.h MIMX8MM6_cm4.h MIMX8MM6_cm4_features.h system_MIMX8MM6_cm4.c system_MIMX8MM6_cm4.h
  group utilities
    ../../../../../../devices/MIMX8MM6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8MM6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMX8MM6/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8MM6/iar/: startup_MIMX8MM6_cm4.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
