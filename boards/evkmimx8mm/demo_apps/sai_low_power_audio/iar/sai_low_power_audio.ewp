# IAR project sai_low_power_audio.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MM6_M4 NXP MIMX8MM6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; NOT_CONFIG_CLK_ROOT=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; SERIAL_PORT_TYPE_UART=1; CODEC_AK4497_ENABLE; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8524_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMX8MM6/drivers; ../../../../../components/srtm/channels; ../../../../../components/srtm/services; ../../../../../components/codec; ../../../../../components/codec/port; ../../../../../components/codec/i2c; ../../../../../components/i2c; ../../../../../components/codec/port/ak4497; ../../../../../components/codec/port/wm8524; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../devices/MIMX8MM6; ../../../../../devices/MIMX8MM6/utilities/str; ../../../../../devices/MIMX8MM6/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Core/Include; ../../../../../components/codec/ak4497; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../components/srtm/port; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mm_m4; ../../../../../components/codec/wm8524
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: sai_low_power_audio.out
  ILINK.IlinkIcfFile: MIMX8MM6xxxxx_cm4_lpa_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MM6DVTLZ; CPU_MIMX8MM6DVTLZ_cm4; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; NOT_CONFIG_CLK_ROOT=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; SERIAL_PORT_TYPE_UART=1; CODEC_AK4497_ENABLE; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8524_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  group source
    ../: FreeRTOSConfig.h rpmsg_config.h lpm.c lpm.h sai_low_power_audio.c sai_low_power_audio.h app_srtm.c app_srtm.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_iomuxc.h
  group remoteproc
    ../: rsc_table.c rsc_table.h remoteproc.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8MM6/drivers/: fsl_gpio.h fsl_gpio.c fsl_uart.h fsl_uart.c fsl_gpc.c fsl_gpc.h fsl_gpt.c fsl_gpt.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_pdm_sdma.h fsl_pdm_sdma.c fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_sai_sdma.h fsl_sai_sdma.c fsl_rdc.h fsl_rdc.c fsl_sdma.h fsl_sdma_script.h fsl_sdma.c fsl_memory.h fsl_mu.h fsl_mu.c fsl_i2c.h fsl_i2c.c fsl_pdm.h fsl_pdm.c
  group drivers/freertos
    ../../../../../devices/MIMX8MM6/drivers/: fsl_i2c_freertos.h fsl_i2c_freertos.c
  group srtm/channels
    ../../../../../components/srtm/channels/: srtm_rpmsg_endpoint.h srtm_rpmsg_endpoint.c
  group srtm/services
    ../../../../../components/srtm/services/: srtm_audio_service.h srtm_audio_service.c srtm_sai_sdma_adapter.h srtm_sai_sdma_adapter.c srtm_pdm_sdma_adapter.h srtm_pdm_sdma_adapter.c srtm_i2c_codec_adapter.h srtm_i2c_codec_adapter.c srtm_wm8524_adapter.h srtm_wm8524_adapter.c
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_mutex_freertos.c srtm_sem_freertos.c srtm_message_pool.c srtm_config.h
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_message.c srtm_message_struct.h srtm_peercore.c srtm_peercore_struct.h srtm_service.c srtm_service_struct.h srtm_heap.h srtm_message_pool.h srtm_list.h srtm_mutex.h srtm_sem.h
  group codec
    ../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../components/codec/ak4497/: fsl_ak4497.h fsl_ak4497.c
    ../../../../../components/codec/wm8524/: fsl_wm8524.h fsl_wm8524.c
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h fsl_codec_adapter.h
  group codec/port/ak4497
    ../../../../../components/codec/port/ak4497/: fsl_codec_ak4497_adapter.c fsl_codec_ak4497_adapter.h
  group codec/port/wm8524
    ../../../../../components/codec/port/wm8524/: fsl_codec_wm8524_adapter.c fsl_codec_wm8524_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_ii2c.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_iuart.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group rpmsg_lite/include
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_lite.h rpmsg_ns.h llist.h rpmsg_default_config.h virtio_ring.h virtqueue.h rpmsg_compiler.h rpmsg_env.h rpmsg_queue.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/include/platform/imx8mm_m4
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mm_m4/: rpmsg_platform.h
  group rpmsg_lite/common
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/rpmsg_lite/porting/platform/imx8mm_m4
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mm_m4/: rpmsg_platform.c
  group rpmsg_lite/virtio
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group device
    ../../../../../devices/MIMX8MM6/: fsl_device_registers.h MIMX8MM6_cm4.h MIMX8MM6_cm4_features.h system_MIMX8MM6_cm4.c system_MIMX8MM6_cm4.h
  group utilities
    ../../../../../devices/MIMX8MM6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX8MM6/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8MM6/utilities/: fsl_assert.c
  group startup
    ../../../../../devices/MIMX8MM6/iar/: startup_MIMX8MM6_cm4.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: ReadMe.url heap_4.c
